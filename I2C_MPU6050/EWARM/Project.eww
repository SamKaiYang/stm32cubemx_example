<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\I2C_MPU6050.ewp</path>
  </project>
  <batchBuild />
</workspace>
